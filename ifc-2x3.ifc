Properties of the parts of a building model (IFC2X3)

# File
Description: Tauchhülse, 150 mm, Ms vernickelt mit Einstich, Durchmesser InnenxAußen 6,5 x 8 mm, ViewDefinition[CoordinationView]
File name: ifc-2x3.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: G9990030, Tauchhülse, 150 mm, Ms vernickelt mit Einstich, Durchmesser InnenxAußen 6,5 x 8 mm
In: Raum
Description: Tauchhülse, 150 mm, Ms vernickelt mit Einstich, Durchmesser Innen x Außen 6,5 x 8 mm, für Hülsenfühler HF und Kabelfühler KF mit Durchmesser 6 mm sowie Einbau- und Industriekanalfühler EKF/IKF; Classification: EC010502 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: G9990030; ModelLabel: THMs/150; GlobalTradeItemNumber: 4050528043962; ProductURL: https://alre.de/produkt_G9990030
Pset_Specification - NominalLength: 0.163 m; NominalWidth: 0.022 m; NominalDepth: 0.022 m; NetWeight: 0.096
Pset_ALRE_ETIM_Properties - Außendurchmesser: 8; Innendurchmesser: 6.5; Druckstufe Artikel: PN 20; Material Tauchrohr: Messing; Einstecklänge: 150; Nenndurchmesser Anschluss: 1/2 Zoll (15); ETIM-Klasse: EC010502; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-G9990030.pdf
